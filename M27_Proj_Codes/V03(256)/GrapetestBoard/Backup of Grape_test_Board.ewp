# IAR project Backup of Grape_test_Board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: BSP\ST\STM32\inc; BSP\uCOS-III; uCOS-iii_Grape_Test_V01; ..\uC-CPU\ARM-Cortex-M3\IAR; ..\uC-CPU; ..\uC-LIB; ..\uCOS-III\Source; ..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; BSP; BSP\uCOS-III; uCOS-iii_Grape_Test_V01
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Grape_test_Board.srec
  ILINK.IlinkOutputFile: Grape_test_Board.out
  ILINK.IlinkIcfFile: BSP\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    uCOS-iii_Grape_Test_V01/: app.c app_vect.c includes.h os_app_hooks.c os_app_hooks.h
  group APP/CFG
    uCOS-iii_Grape_Test_V01/: app.h app_cfg.h os_cfg_app.h stm32f10x_conf.h
  group BSP
    BSP/: STM32_FLASH.icf
  group BSP/Headers
    BSP/: bsp.h bsp_Controltargetconf.h bsp_iicbusdrive.h bsp_keyscan.h bsp_motioncontrol.h bsp_ser.h modbus.h sys.h
    BSP/uCOS-III/: bsp_os.h
  group BSP/Source
    BSP/: bsp.c bsp_IICbusDrive.c bsp_int.c bsp_keyscan.c bsp_motioncontrol.c bsp_periph.c bsp_ser.c modbus.c
    BSP/uCOS-III/: bsp_os.c
  group BSP/Stm32 Library/inc
    BSP/ST/STM32/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/Stm32 Library/src
    BSP/ST/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CFG-LIBRARIES
    uCOS-iii_Grape_Test_V01/: cpu_cfg.h lib_cfg.h os_cfg.h os_type.h
  group uC/CPU/Headers
    ../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    ../uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    ../uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    ../uC-CPU/: cpu_core.c
  group uC/LIB/Headers
    ../uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III
    ../uCOS-III/Source/: os_cfg_app.c
  group uC/OS-III/Headers
    ../uCOS-III/Source/: os.h
    ../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    ../uCOS-III/Source/: os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
